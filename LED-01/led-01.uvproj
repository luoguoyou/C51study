# Keil uVision project led-01.uvproj, settings and files
target led-01 (MCS-51)
  device: STC8H1K28 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x6FF8) CLOCK(35000000)
  output: led-01 +hex
  c flags: Optimize=8 SizeSpeed=1
  group user
    ./: STARTUP.A51
    ./user/: main.c
