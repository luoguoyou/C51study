# Keil uVision project timer-led.uvproj, settings and files
target timer-led (MCS-51)
  device: STC8H1K28 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x6FF8) CLOCK(35000000)
  output: timer-led +hex
  c flags: Optimize=8 SizeSpeed=1
  group user
    ./: STARTUP.A51 main.c
