# Keil uVision project key-01.uvproj, settings and files
target key-01 (MCS-51)
  device: STC8H1K28 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x6FF8) CLOCK(35000000)
  output: key-02 +hex
  c flags: Optimize=8 SizeSpeed=1
  group user
    ./: STARTUP.A51 main（2）.c
